# Keil uVision project Radio_Rebuild_Stm32CubeMX.uvprojx, settings and files
target Radio_Rebuild_Stm32CubeMX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Radio_Rebuild_Stm32CubeMX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,HAVE_CONFIG_H
  c include: ../Inc;          ../Drivers/STM32F4xx_HAL_Driver/Inc;          ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;          ../Drivers/CMSIS/Include;          ../Middlewares/Third_Party/FatFs/src;          ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;          ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;          ..\SelfCode;          ..\SelfCode\Source\Factory;          ..\SelfCode\Source\Factory\inc;          ..\SelfCode\Source\BasicDataStream\inc;          ..\SelfCode\Speex_Lib\include;          ..\SelfCode\Speex_Lib\libspeex;          ..\SelfCode\Speex_Lib\STM32;          ..\SelfCode\Speex_Lib\STM32\include;          ..\SelfCode\Speex_Lib\STM32\libspeex;          ..\SelfCode\Speex_Lib\STM32\libspeex\arm;          ..\SelfCode\OLED;          ..\SelfCode\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: main.c bsp_driver_sd.c sd_diskio.c fatfs.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_mmc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc950.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group self
    ../SelfCode/: wav.c fatfs_write_wav.c malloc.c
    ../SelfCode/Source/Factory/src/: basic_function.c
    ../SelfCode/Source/BasicDataStream/src/: ringbuffer.c
    ../SelfCode/OLED/: oled.c
    ../SelfCode/STMFLASH/: stmflash.c
  group libspeex
    ../SelfCode/Speex_Lib/libspeex/: bits.c buffer.c exc_10_32_table.c gain_table_lbr.c high_lsp_tables.c lpc.c lsp.c speex.c speex_callbacks.c speex_header.c window.c lsp_tables_nb.c
    ../SelfCode/Speex_Lib/STM32/libspeex/: cb_search.c filters.c ltp.c modes.c nb_celp.c quant_lsp.c vq.c
software components: CMSIS:CORE 4.3.0
